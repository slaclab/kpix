* Project W_SI_CHIP_DRIVER
* Powerview Wirelist Created with Version 6.1
* Inifile   : wspice.ini
* Options   : -nrvx
* Levels    :
*

R1000    RESET_C  RST         10
R1001    COMMAND_C CMD        10
R1002    RDBACK_C READBACK_C  10

RBA2     SYSCLK_P BALB  21K
RBA3     BALB SYSCLK_M  21K
CBA1     BXN 0    1PF
CBA2     BALB 0    .386PF
CBA3     BAB19 0    .386PF
CBA4     BAB18 EVDD  .102PF
CBAV     EVDD 0    11.4PF
CBA5     BX15 EVDD  .386PF
MBAPU1   BALA BAB18 EVDD EVDD  PM W=.72U L=.72U AD=.52P AS=.52P PD=2.9U
+ PS=2.9U M=1
MBAPU2   BALC BALB BALA BALA  PM W=.72U L=.72U AD=.52P AS=.52P PD=2.9U
+ PS=2.9U M=2
MBAPU3   BXN BAB19 BALA BALA  PM W=.72U L=.72U AD=.52P AS=.52P PD=2.9U
+ PS=2.9U M=2
MBANU1   0   BALC BALC  G_SUB NM W=.72U L=.72U AD=.52P AS=.52P PD=2.9U PS=2.9U
+ M=1
MBANU2   0   BALC BXN  G_SUB NM W=.72U L=.72U AD=.52P AS=.52P PD=2.9U PS=2.9U
+ M=1
MBAPU4   BAB18 BAB18 EVDD EVDD  PM W=.72U L=.72U AD=.52P AS=.52P PD=2.9U
+ PS=2.9U M=20
MBAPT1   BX15 BX15 EVDD EVDD  PM W=6U L=.24U AD=.8P AS=.8P PD=3.8U PS=3.8U
+ M=1
RBA1     BAB18 0    504K
C7       BAB18 EVDD  102FF
RBA4     EVDD BAB19  30K
RBA5     BAB19 0    28K
C8       BAB19 0    .386PF
MI5PT1   GX2 EXT_CLK EVDD EVDD  PM W=1.2U L=.24U AD=.8P AS=.8P PD=3.8U PS=3.8U
+ M=1
MI5NT1   G_DGND EXT_CLK GX2  G_SUB NM W=.72U L=.24U AD=.5P AS=.5P PD=2.8U PS=2.8U M=1
RS4       BX15 0    4K
MXJPT1   XJL3 BX15 EVDD EVDD  PM W=6U L=.24U AD=.8P AS=.8P PD=3.8U PS=3.8U
+ M=3
MXJPT3   SYSCLK_P GX2 XJL3 EVDD  PM W=6U L=.24U AD=.8P AS=.8P PD=3.8U PS=3.8U
+ M=3
MXJNT3   XJL4 GX2 SYSCLK_P  G_SUB NM W=3U L=.24U AD=.5P AS=.5P PD=2.8U PS=2.8U
+ M=3
MXJNT4   XJL4 EXT_CLK SYSCLK_M  G_SUB NM W=3U L=.24U AD=.5P AS=.5P PD=2.8U PS=2.8U
+ M=3
MXJNT1   0   BXN XJL4  G_SUB NM W=3U L=.24U AD=.5P AS=.5P PD=2.8U PS=2.8U M=3
MXJPT4   SYSCLK_M EXT_CLK XJL3 EVDD  PM W=6U L=.24U AD=.8P AS=.8P PD=3.8U PS=3.8U
+ M=3
R1       G_SUB2 0    0
R11      G_SUB  0    0
VBAVDD   AVDD AGND   2.5V
VVGA     BVDD BGND   2.5V
VBVDD    G_DVDD G_DGND   1.8V
VBVREF   AVDD VREFM  2.5009V
R3       BGND 0    0
R2       G_DGND 0    0
R0       AGND 0    0
VBEVDD   EVDD 0    2.5V
RS5      SYSCLK_P SYSCLK_M  100
C6       SYSCLK_M 0         10PF
C2       SYSCLK_P 0         10PF
C5       SYSCLK_P SYSCLK_M  500FF

* Extra connections to ground
* RUAB  UAB  0 0
* RUIB  UIB  0 0
* RUJB  UJB  0 0
* RUKB  UKB  0 0
* RULB  ULB  0 0
* RUMB  UMB  0 0
* RUNB  UNB  0 0
* RUBAB UBAB 0 0
* RUGAB UGAB 0 0
* RUHAB UHAB 0 0
* RUIIB UIIB 0 0
* RUJJB UJJB 0 0
* RUKKB UKKB 0 0
* RULLB ULLB 0 0
* RUMMB UMMB 0 0
* RUNNB UNNB 0 0
* RUUAB UUAB 0 0
* RUVAB UVAB 0 0
* RUWAB UWAB 0 0
* RUXAB UXAB 0 0

* Trigger Force
VTRIGP X_TRIG_P 0 0V
VTRIGM X_TRIG_M 0 2.5V

CP0      PIXEL0    AVDD 20PF
CP1      PIXEL1    AVDD 20PF
CP2      PIXEL2    AVDD 20PF
CP3      PIXEL3    AVDD 20PF
CP4      PIXEL4    AVDD 20PF
CP5      PIXEL5    AVDD 20PF
CP6      PIXEL6    AVDD 20PF
CP7      PIXEL7    AVDD 20PF
CP8      PIXEL8    AVDD 20PF
CP9      PIXEL9    AVDD 20PF
CP10     PIXEL10   AVDD 20PF
CP11     PIXEL11   AVDD 20PF
CP12     PIXEL12   AVDD 20PF
CP13     PIXEL13   AVDD 20PF
CP14     PIXEL14   AVDD 20PF
CP15     PIXEL15   AVDD 20PF
CP16     PIXEL16   AVDD 20PF
CP17     PIXEL17   AVDD 20PF
CP18     PIXEL18   AVDD 20PF
CP19     PIXEL19   AVDD 20PF
CP20     PIXEL20   AVDD 20PF
CP21     PIXEL21   AVDD 20PF
CP22     PIXEL22   AVDD 20PF
CP23     PIXEL23   AVDD 20PF
CP24     PIXEL24   AVDD 20PF
CP25     PIXEL25   AVDD 20PF
CP26     PIXEL26   AVDD 20PF
CP27     PIXEL27   AVDD 20PF
CP28     PIXEL28   AVDD 20PF
CP29     PIXEL29   AVDD 20PF
CP30     PIXEL30   AVDD 20PF
CP31     PIXEL31   AVDD 20PF
CP32     PIXEL32   AVDD 21PF
CP33     PIXEL33   AVDD 21PF
CP34     PIXEL34   AVDD 21PF
CP35     PIXEL35   AVDD 21PF
CP36     PIXEL36   AVDD 21PF
CP37     PIXEL37   AVDD 21PF
CP38     PIXEL38   AVDD 21PF
CP39     PIXEL39   AVDD 21PF
CP40     PIXEL40   AVDD 21PF
CP41     PIXEL41   AVDD 21PF
CP42     PIXEL42   AVDD 21PF
CP43     PIXEL43   AVDD 21PF
CP44     PIXEL44   AVDD 21PF
CP45     PIXEL45   AVDD 21PF
CP46     PIXEL46   AVDD 21PF
CP47     PIXEL47   AVDD 21PF
CP48     PIXEL48   AVDD 21PF
CP49     PIXEL49   AVDD 21PF
CP50     PIXEL50   AVDD 21PF
CP51     PIXEL51   AVDD 21PF
CP52     PIXEL52   AVDD 21PF
CP53     PIXEL53   AVDD 21PF
CP54     PIXEL54   AVDD 21PF
CP55     PIXEL55   AVDD 21PF
CP56     PIXEL56   AVDD 21PF
CP57     PIXEL57   AVDD 21PF
CP58     PIXEL58   AVDD 21PF
CP59     PIXEL59   AVDD 21PF
CP60     PIXEL60   AVDD 21PF
CP61     PIXEL61   AVDD 21PF
CP62     PIXEL62   AVDD 21PF
CP63     PIXEL63   AVDD 21PF
CP64     PIXEL64   AVDD 22PF
CP65     PIXEL65   AVDD 22PF
CP66     PIXEL66   AVDD 22PF
CP67     PIXEL67   AVDD 22PF
CP68     PIXEL68   AVDD 22PF
CP69     PIXEL69   AVDD 22PF
CP70     PIXEL70   AVDD 22PF
CP71     PIXEL71   AVDD 22PF
CP72     PIXEL72   AVDD 22PF
CP73     PIXEL73   AVDD 22PF
CP74     PIXEL74   AVDD 22PF
CP75     PIXEL75   AVDD 22PF
CP76     PIXEL76   AVDD 22PF
CP77     PIXEL77   AVDD 22PF
CP78     PIXEL78   AVDD 22PF
CP79     PIXEL79   AVDD 22PF
CP80     PIXEL80   AVDD 22PF
CP81     PIXEL81   AVDD 22PF
CP82     PIXEL82   AVDD 22PF
CP83     PIXEL83   AVDD 22PF
CP84     PIXEL84   AVDD 22PF
CP85     PIXEL85   AVDD 22PF
CP86     PIXEL86   AVDD 22PF
CP87     PIXEL87   AVDD 22PF
CP88     PIXEL88   AVDD 22PF
CP89     PIXEL89   AVDD 22PF
CP90     PIXEL90   AVDD 22PF
CP91     PIXEL91   AVDD 22PF
CP92     PIXEL92   AVDD 22PF
CP93     PIXEL93   AVDD 22PF
CP94     PIXEL94   AVDD 22PF
CP95     PIXEL95   AVDD 22PF
CP96     PIXEL96   AVDD 23PF
CP97     PIXEL97   AVDD 23PF
CP98     PIXEL98   AVDD 23PF
CP99     PIXEL99   AVDD 23PF
CP100    PIXEL100  AVDD 23PF
CP101    PIXEL101  AVDD 23PF
CP102    PIXEL102  AVDD 23PF
CP103    PIXEL103  AVDD 23PF
CP104    PIXEL104  AVDD 23PF
CP105    PIXEL105  AVDD 23PF
CP106    PIXEL106  AVDD 23PF
CP107    PIXEL107  AVDD 23PF
CP108    PIXEL108  AVDD 23PF
CP109    PIXEL109  AVDD 23PF
CP110    PIXEL110  AVDD 23PF
CP111    PIXEL111  AVDD 23PF
CP112    PIXEL112  AVDD 23PF
CP113    PIXEL113  AVDD 23PF
CP114    PIXEL114  AVDD 23PF
CP115    PIXEL115  AVDD 23PF
CP116    PIXEL116  AVDD 23PF
CP117    PIXEL117  AVDD 23PF
CP118    PIXEL118  AVDD 23PF
CP119    PIXEL119  AVDD 23PF
CP120    PIXEL120  AVDD 23PF
CP121    PIXEL121  AVDD 23PF
CP122    PIXEL122  AVDD 23PF
CP123    PIXEL123  AVDD 23PF
CP124    PIXEL124  AVDD 23PF
CP125    PIXEL125  AVDD 23PF
CP126    PIXEL126  AVDD 23PF
CP127    PIXEL127  AVDD 23PF
CP128    PIXEL128  AVDD 24PF
CP129    PIXEL129  AVDD 24PF
CP130    PIXEL130  AVDD 24PF
CP131    PIXEL131  AVDD 24PF
CP132    PIXEL132  AVDD 24PF
CP133    PIXEL133  AVDD 24PF
CP134    PIXEL134  AVDD 24PF
CP135    PIXEL135  AVDD 24PF
CP136    PIXEL136  AVDD 24PF
CP137    PIXEL137  AVDD 24PF
CP138    PIXEL138  AVDD 24PF
CP139    PIXEL139  AVDD 24PF
CP140    PIXEL140  AVDD 24PF
CP141    PIXEL141  AVDD 24PF
CP142    PIXEL142  AVDD 24PF
CP143    PIXEL143  AVDD 24PF
CP144    PIXEL144  AVDD 24PF
CP145    PIXEL145  AVDD 24PF
CP146    PIXEL146  AVDD 24PF
CP147    PIXEL147  AVDD 24PF
CP148    PIXEL148  AVDD 24PF
CP149    PIXEL149  AVDD 24PF
CP150    PIXEL150  AVDD 24PF
CP151    PIXEL151  AVDD 24PF
CP152    PIXEL152  AVDD 24PF
CP153    PIXEL153  AVDD 24PF
CP154    PIXEL154  AVDD 24PF
CP155    PIXEL155  AVDD 24PF
CP156    PIXEL156  AVDD 25PF
CP157    PIXEL157  AVDD 25PF
CP158    PIXEL158  AVDD 25PF
CP159    PIXEL159  AVDD 25PF
CP160    PIXEL160  AVDD 25PF
CP161    PIXEL161  AVDD 25PF
CP162    PIXEL162  AVDD 25PF
CP163    PIXEL163  AVDD 25PF
CP164    PIXEL164  AVDD 25PF
CP165    PIXEL165  AVDD 25PF
CP166    PIXEL166  AVDD 25PF
CP167    PIXEL167  AVDD 25PF
CP168    PIXEL168  AVDD 25PF
CP169    PIXEL169  AVDD 25PF
CP170    PIXEL170  AVDD 25PF
CP171    PIXEL171  AVDD 25PF
CP172    PIXEL172  AVDD 25PF
CP173    PIXEL173  AVDD 25PF
CP174    PIXEL174  AVDD 25PF
CP175    PIXEL175  AVDD 25PF
CP176    PIXEL176  AVDD 25PF
CP177    PIXEL177  AVDD 25PF
CP178    PIXEL178  AVDD 25PF
CP179    PIXEL179  AVDD 25PF
CP180    PIXEL180  AVDD 25PF
CP181    PIXEL181  AVDD 25PF
CP182    PIXEL182  AVDD 25PF
CP183    PIXEL183  AVDD 25PF
CP184    PIXEL184  AVDD 25PF
CP185    PIXEL185  AVDD 25PF
CP186    PIXEL186  AVDD 25PF
CP187    PIXEL187  AVDD 25PF
CP188    PIXEL188  AVDD 25PF
CP189    PIXEL189  AVDD 25PF
CP190    PIXEL190  AVDD 25PF
CP191    PIXEL191  AVDD 25PF
CP192    PIXEL192  AVDD 26PF
CP193    PIXEL193  AVDD 26PF
CP194    PIXEL194  AVDD 26PF
CP195    PIXEL195  AVDD 26PF
CP196    PIXEL196  AVDD 26PF
CP197    PIXEL197  AVDD 26PF
CP198    PIXEL198  AVDD 26PF
CP199    PIXEL199  AVDD 26PF
CP200    PIXEL200  AVDD 26PF
CP201    PIXEL201  AVDD 26PF
CP202    PIXEL202  AVDD 26PF
CP203    PIXEL203  AVDD 26PF
CP204    PIXEL204  AVDD 26PF
CP205    PIXEL205  AVDD 26PF
CP206    PIXEL206  AVDD 26PF
CP207    PIXEL207  AVDD 26PF
CP208    PIXEL208  AVDD 26PF
CP209    PIXEL209  AVDD 26PF
CP210    PIXEL210  AVDD 26PF
CP211    PIXEL211  AVDD 26PF
CP212    PIXEL212  AVDD 26PF
CP213    PIXEL213  AVDD 26PF
CP214    PIXEL214  AVDD 26PF
CP215    PIXEL215  AVDD 26PF
CP216    PIXEL216  AVDD 26PF
CP217    PIXEL217  AVDD 26PF
CP218    PIXEL218  AVDD 26PF
CP219    PIXEL219  AVDD 26PF
CP220    PIXEL220  AVDD 26PF
CP221    PIXEL221  AVDD 26PF
CP222    PIXEL222  AVDD 26PF
CP223    PIXEL223  AVDD 26PF
CP224    PIXEL224  AVDD 27PF
CP225    PIXEL225  AVDD 27PF
CP226    PIXEL226  AVDD 27PF
CP227    PIXEL227  AVDD 27PF
CP228    PIXEL228  AVDD 27PF
CP229    PIXEL229  AVDD 27PF
CP230    PIXEL230  AVDD 27PF
CP231    PIXEL231  AVDD 27PF
CP232    PIXEL232  AVDD 27PF
CP233    PIXEL233  AVDD 27PF
CP234    PIXEL234  AVDD 27PF
CP235    PIXEL235  AVDD 27PF
CP236    PIXEL236  AVDD 27PF
CP237    PIXEL237  AVDD 27PF
CP238    PIXEL238  AVDD 27PF
CP239    PIXEL239  AVDD 27PF
CP240    PIXEL240  AVDD 27PF
CP241    PIXEL241  AVDD 27PF
CP242    PIXEL242  AVDD 27PF
CP243    PIXEL243  AVDD 27PF
CP244    PIXEL244  AVDD 27PF
CP245    PIXEL245  AVDD 27PF
CP246    PIXEL246  AVDD 27PF
CP247    PIXEL247  AVDD 27PF
CP248    PIXEL248  AVDD 27PF
CP249    PIXEL249  AVDD 27PF
CP250    PIXEL250  AVDD 27PF
CP251    PIXEL251  AVDD 27PF
CP252    PIXEL252  AVDD 27PF
CP253    PIXEL253  AVDD 27PF
CP254    PIXEL254  AVDD 27PF
CP255    PIXEL255  AVDD 27PF
CP256    PIXEL256  AVDD 25PF
CP257    PIXEL257  AVDD 25PF
CP258    PIXEL258  AVDD 25PF
CP259    PIXEL259  AVDD 25PF
CP260    PIXEL260  AVDD 25PF
CP261    PIXEL261  AVDD 25PF
CP262    PIXEL262  AVDD 25PF
CP263    PIXEL263  AVDD 25PF
CP264    PIXEL264  AVDD 25PF
CP265    PIXEL265  AVDD 25PF
CP266    PIXEL266  AVDD 25PF
CP267    PIXEL267  AVDD 25PF
CP268    PIXEL268  AVDD 25PF
CP269    PIXEL269  AVDD 25PF
CP270    PIXEL270  AVDD 25PF
CP271    PIXEL271  AVDD 25PF
CP272    PIXEL272  AVDD 25PF
CP273    PIXEL273  AVDD 25PF
CP274    PIXEL274  AVDD 25PF
CP275    PIXEL275  AVDD 25PF
CP276    PIXEL276  AVDD 25PF
CP277    PIXEL277  AVDD 25PF
CP278    PIXEL278  AVDD 25PF
CP279    PIXEL279  AVDD 25PF
CP280    PIXEL280  AVDD 25PF
CP281    PIXEL281  AVDD 25PF
CP282    PIXEL282  AVDD 25PF
CP283    PIXEL283  AVDD 25PF
CP284    PIXEL284  AVDD 25PF
CP285    PIXEL285  AVDD 25PF
CP286    PIXEL286  AVDD 25PF
CP287    PIXEL287  AVDD 25PF
CP288    PIXEL288  AVDD 25PF
CP289    PIXEL289  AVDD 25PF
CP290    PIXEL290  AVDD 25PF
CP291    PIXEL291  AVDD 25PF
CP292    PIXEL292  AVDD 26PF
CP293    PIXEL293  AVDD 26PF
CP294    PIXEL294  AVDD 26PF
CP295    PIXEL295  AVDD 26PF
CP296    PIXEL296  AVDD 26PF
CP297    PIXEL297  AVDD 26PF
CP298    PIXEL298  AVDD 26PF
CP299    PIXEL299  AVDD 26PF
CP300    PIXEL300  AVDD 23PF
CP301    PIXEL301  AVDD 23PF
CP302    PIXEL302  AVDD 23PF
CP303    PIXEL303  AVDD 23PF
CP304    PIXEL304  AVDD 23PF
CP305    PIXEL305  AVDD 23PF
CP306    PIXEL306  AVDD 23PF
CP307    PIXEL307  AVDD 23PF
CP308    PIXEL308  AVDD 23PF
CP309    PIXEL309  AVDD 23PF
CP310    PIXEL310  AVDD 23PF
CP311    PIXEL311  AVDD 23PF
CP312    PIXEL312  AVDD 23PF
CP313    PIXEL313  AVDD 23PF
CP314    PIXEL314  AVDD 23PF
CP315    PIXEL315  AVDD 23PF
CP316    PIXEL316  AVDD 23PF
CP317    PIXEL317  AVDD 23PF
CP318    PIXEL318  AVDD 23PF
CP319    PIXEL319  AVDD 23PF
CP320    PIXEL320  AVDD 23PF
CP321    PIXEL321  AVDD 23PF
CP322    PIXEL322  AVDD 23PF
CP323    PIXEL323  AVDD 23PF
CP324    PIXEL324  AVDD 23PF
CP325    PIXEL325  AVDD 23PF
CP326    PIXEL326  AVDD 23PF
CP327    PIXEL327  AVDD 23PF
CP328    PIXEL328  AVDD 24PF
CP329    PIXEL329  AVDD 24PF
CP330    PIXEL330  AVDD 24PF
CP331    PIXEL331  AVDD 24PF
CP332    PIXEL332  AVDD 24PF
CP333    PIXEL333  AVDD 24PF
CP334    PIXEL334  AVDD 24PF
CP335    PIXEL335  AVDD 24PF
CP336    PIXEL336  AVDD 24PF
CP337    PIXEL337  AVDD 24PF
CP338    PIXEL338  AVDD 24PF
CP339    PIXEL339  AVDD 24PF
CP340    PIXEL340  AVDD 24PF
CP341    PIXEL341  AVDD 24PF
CP342    PIXEL342  AVDD 24PF
CP343    PIXEL343  AVDD 24PF
CP344    PIXEL344  AVDD 24PF
CP345    PIXEL345  AVDD 24PF
CP346    PIXEL346  AVDD 24PF
CP347    PIXEL347  AVDD 24PF
CP348    PIXEL348  AVDD 24PF
CP349    PIXEL349  AVDD 24PF
CP350    PIXEL350  AVDD 24PF
CP351    PIXEL351  AVDD 24PF
CP352    PIXEL352  AVDD 24PF
CP353    PIXEL353  AVDD 24PF
CP354    PIXEL354  AVDD 24PF
CP355    PIXEL355  AVDD 24PF
CP356    PIXEL356  AVDD 25PF
CP357    PIXEL357  AVDD 25PF
CP358    PIXEL358  AVDD 25PF
CP359    PIXEL359  AVDD 25PF
CP360    PIXEL360  AVDD 25PF
CP361    PIXEL361  AVDD 25PF
CP362    PIXEL362  AVDD 25PF
CP363    PIXEL363  AVDD 25PF
CP364    PIXEL364  AVDD 25PF
CP365    PIXEL365  AVDD 25PF
CP366    PIXEL366  AVDD 25PF
CP367    PIXEL367  AVDD 25PF
CP368    PIXEL368  AVDD 25PF
CP369    PIXEL369  AVDD 25PF
CP370    PIXEL370  AVDD 25PF
CP371    PIXEL371  AVDD 25PF
CP372    PIXEL372  AVDD 25PF
CP373    PIXEL373  AVDD 25PF
CP374    PIXEL374  AVDD 25PF
CP375    PIXEL375  AVDD 25PF
CP376    PIXEL376  AVDD 25PF
CP377    PIXEL377  AVDD 25PF
CP378    PIXEL378  AVDD 25PF
CP379    PIXEL379  AVDD 25PF
CP380    PIXEL380  AVDD 25PF
CP381    PIXEL381  AVDD 25PF
CP382    PIXEL382  AVDD 25PF
CP383    PIXEL383  AVDD 25PF
CP384    PIXEL384  AVDD 25PF
CP385    PIXEL385  AVDD 25PF
CP386    PIXEL386  AVDD 25PF
CP387    PIXEL387  AVDD 25PF
CP388    PIXEL388  AVDD 25PF
CP389    PIXEL389  AVDD 25PF
CP390    PIXEL390  AVDD 25PF
CP391    PIXEL391  AVDD 25PF
CP392    PIXEL392  AVDD 26PF
CP393    PIXEL393  AVDD 26PF
CP394    PIXEL394  AVDD 26PF
CP395    PIXEL395  AVDD 26PF
CP396    PIXEL396  AVDD 26PF
CP397    PIXEL397  AVDD 26PF
CP398    PIXEL398  AVDD 26PF
CP399    PIXEL399  AVDD 26PF
CP400    PIXEL400  AVDD 23PF
CP401    PIXEL401  AVDD 23PF
CP402    PIXEL402  AVDD 23PF
CP403    PIXEL403  AVDD 23PF
CP404    PIXEL404  AVDD 23PF
CP405    PIXEL405  AVDD 23PF
CP406    PIXEL406  AVDD 23PF
CP407    PIXEL407  AVDD 23PF
CP408    PIXEL408  AVDD 23PF
CP409    PIXEL409  AVDD 23PF
CP410    PIXEL410  AVDD 23PF
CP411    PIXEL411  AVDD 23PF
CP412    PIXEL412  AVDD 23PF
CP413    PIXEL413  AVDD 23PF
CP414    PIXEL414  AVDD 23PF
CP415    PIXEL415  AVDD 23PF
CP416    PIXEL416  AVDD 23PF
CP417    PIXEL417  AVDD 23PF
CP418    PIXEL418  AVDD 23PF
CP419    PIXEL419  AVDD 23PF
CP420    PIXEL420  AVDD 23PF
CP421    PIXEL421  AVDD 23PF
CP422    PIXEL422  AVDD 23PF
CP423    PIXEL423  AVDD 23PF
CP424    PIXEL424  AVDD 23PF
CP425    PIXEL425  AVDD 23PF
CP426    PIXEL426  AVDD 23PF
CP427    PIXEL427  AVDD 23PF
CP428    PIXEL428  AVDD 24PF
CP429    PIXEL429  AVDD 24PF
CP430    PIXEL430  AVDD 24PF
CP431    PIXEL431  AVDD 24PF
CP432    PIXEL432  AVDD 24PF
CP433    PIXEL433  AVDD 24PF
CP434    PIXEL434  AVDD 24PF
CP435    PIXEL435  AVDD 24PF
CP436    PIXEL436  AVDD 24PF
CP437    PIXEL437  AVDD 24PF
CP438    PIXEL438  AVDD 24PF
CP439    PIXEL439  AVDD 24PF
CP440    PIXEL440  AVDD 24PF
CP441    PIXEL441  AVDD 24PF
CP442    PIXEL442  AVDD 24PF
CP443    PIXEL443  AVDD 24PF
CP444    PIXEL444  AVDD 24PF
CP445    PIXEL445  AVDD 24PF
CP446    PIXEL446  AVDD 24PF
CP447    PIXEL447  AVDD 24PF
CP448    PIXEL448  AVDD 24PF
CP449    PIXEL449  AVDD 24PF
CP450    PIXEL450  AVDD 24PF
CP451    PIXEL451  AVDD 24PF
CP452    PIXEL452  AVDD 24PF
CP453    PIXEL453  AVDD 24PF
CP454    PIXEL454  AVDD 24PF
CP455    PIXEL455  AVDD 24PF
CP456    PIXEL456  AVDD 25PF
CP457    PIXEL457  AVDD 25PF
CP458    PIXEL458  AVDD 25PF
CP459    PIXEL459  AVDD 25PF
CP460    PIXEL460  AVDD 25PF
CP461    PIXEL461  AVDD 25PF
CP462    PIXEL462  AVDD 25PF
CP463    PIXEL463  AVDD 25PF
CP464    PIXEL464  AVDD 25PF
CP465    PIXEL465  AVDD 25PF
CP466    PIXEL466  AVDD 25PF
CP467    PIXEL467  AVDD 25PF
CP468    PIXEL468  AVDD 25PF
CP469    PIXEL469  AVDD 25PF
CP470    PIXEL470  AVDD 25PF
CP471    PIXEL471  AVDD 25PF
CP472    PIXEL472  AVDD 25PF
CP473    PIXEL473  AVDD 25PF
CP474    PIXEL474  AVDD 25PF
CP475    PIXEL475  AVDD 25PF
CP476    PIXEL476  AVDD 25PF
CP477    PIXEL477  AVDD 25PF
CP478    PIXEL478  AVDD 25PF
CP479    PIXEL479  AVDD 25PF
CP480    PIXEL480  AVDD 25PF
CP481    PIXEL481  AVDD 25PF
CP482    PIXEL482  AVDD 25PF
CP483    PIXEL483  AVDD 25PF
CP484    PIXEL484  AVDD 25PF
CP485    PIXEL485  AVDD 25PF
CP486    PIXEL486  AVDD 25PF
CP487    PIXEL487  AVDD 25PF
CP488    PIXEL488  AVDD 25PF
CP489    PIXEL489  AVDD 25PF
CP490    PIXEL490  AVDD 25PF
CP491    PIXEL491  AVDD 25PF
CP492    PIXEL492  AVDD 26PF
CP493    PIXEL493  AVDD 26PF
CP494    PIXEL494  AVDD 26PF
CP495    PIXEL495  AVDD 26PF
CP496    PIXEL496  AVDD 26PF
CP497    PIXEL497  AVDD 26PF
CP498    PIXEL498  AVDD 26PF
CP499    PIXEL499  AVDD 26PF
CP500    PIXEL500  AVDD 23PF
CP501    PIXEL501  AVDD 23PF
CP502    PIXEL502  AVDD 23PF
CP503    PIXEL503  AVDD 23PF
CP504    PIXEL504  AVDD 23PF
CP505    PIXEL505  AVDD 23PF
CP506    PIXEL506  AVDD 23PF
CP507    PIXEL507  AVDD 23PF
CP508    PIXEL508  AVDD 23PF
CP509    PIXEL509  AVDD 23PF
CP510    PIXEL510  AVDD 23PF
CP511    PIXEL511  AVDD 23PF

.END
